# Keil uVision project FireRt-Thread.uvprojx, settings and files
target FireRt-Thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: FireRt-Thread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\rtthread\bsp;..\rtthread\include;..\rtthread\libcpu\arm\cortex-m3;..\rtthread\src;..\User
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c
  group rtt/ports
    ../rtthread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group rtt/source
    ../rtthread/src/: thread.c scheduler.c object.c kservice.c clock.c idle.c irq.c timer.c
    ../rtthread/include/: rtservice.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.1.0
